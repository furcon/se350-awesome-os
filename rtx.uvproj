# Keil uVision project rtx.uvproj, settings and files
target RTX (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: rtx
  c flags: Optim=1
  c include: .\resources
  memory RVCT4: ROM 0x10000000 size 0x4000
  memory RVCT9: RAM 0x10004000 size 0x4000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Startup Code
    ./: startup_LPC17xx.s
  group System Code
    ./resources/manual_code/Startup/: system_LPC17xx.c
  group Source Code
    ./resources/manual_code/UART_polling/: uart_polling.c
    ./: main.c rtx.h rtx.c
